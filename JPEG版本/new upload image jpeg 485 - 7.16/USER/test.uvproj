# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\JOYPAD;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\NRF24L01;..\HARDWARE\PS2;..\HARDWARE\STMFLASH;..\HARDWARE\RDA5820;..\HARDWARE\AUDIOSEL;..\HARDWARE\OV7670;..\HARDWARE\SRAM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c stm32f10x_flash.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/24CXX/: myiic.c 24cxx.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/JOYPAD/: joypad.c
    ../HARDWARE/ADXL345/: adxl345.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/PS2/: ps2.c mouse.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/RDA5820/: rda5820.c
    ../HARDWARE/AUDIOSEL/: audiosel.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/SRAM/: sram.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group Malloc
    ../MALLOC/: malloc.c
  group jpeg
    ../JPEG/: dct.c jcapi.c jchuff.c jcint.c jcmarker.c jpeg_enc.c jutility.c
